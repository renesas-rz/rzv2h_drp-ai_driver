FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append:rzv2n-family = " \
    file://0000-ddr_param_def_lpddr4-rzv2n_1.patch \
"
