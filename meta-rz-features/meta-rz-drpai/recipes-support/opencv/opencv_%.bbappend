PACKAGECONFIG:append:pn-opencv = " gtk python3"
PACKAGECONFIG:append:pn-nativesdk-opencv = " gtk"
